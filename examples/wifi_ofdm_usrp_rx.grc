<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_ofdm_usrp_rx</value></param>
<param><key>author</key><value>Teng-Hui Huang</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>WIFI OFDM USRP Rx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>value</key><value>"addr=192.168.10.2"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>2.6e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>32</value></param>
<param><key>ntaps</key><value>11*4*32</value></param>
<param><key>samp_rate</key><value>32*4</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>value</key><value>"A:0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>2*pi/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import sin, pi</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_subdev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wifi_ofdm_block_decoder_vc</key>
<param><key>id</key><value>wifi_ofdm_block_decoder_vc_0</value></param>
</block>
<block>
<key>wifi_ofdm_coarse_cfo_fixer_cc</key>
<param><key>id</key><value>wifi_ofdm_coarse_cfo_fixer_cc_0</value></param>
<param><key>delay</key><value>32</value></param>
</block>
<block>
<key>wifi_ofdm_ppdu_sink</key>
<param><key>id</key><value>wifi_ofdm_ppdu_sink_0</value></param>
</block>
<block>
<key>wifi_ofdm_symbol_parser_vc</key>
<param><key>id</key><value>wifi_ofdm_symbol_parser_vc_0</value></param>
</block>
<block>
<key>wifi_ofdm_symbol_sync_cvc</key>
<param><key>id</key><value>wifi_ofdm_symbol_sync_cvc_0</value></param>
</block>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>wifi_ofdm_coarse_cfo_fixer_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>wifi_ofdm_coarse_cfo_fixer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>wifi_ofdm_symbol_parser_vc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_block_decoder_vc_0</source_block_id><sink_block_id>wifi_ofdm_ppdu_sink_0</sink_block_id><source_key>ppdu_out</source_key><sink_key>ppdu_in</sink_key></connection>
<connection><source_block_id>wifi_ofdm_coarse_cfo_fixer_cc_0</source_block_id><sink_block_id>wifi_ofdm_symbol_sync_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_ppdu_sink_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>wifi_ofdm_symbol_parser_vc_0</source_block_id><sink_block_id>wifi_ofdm_block_decoder_vc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_symbol_sync_cvc_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
