options:
  parameters:
    author: Teng-Hui Huang
    generate_options: qt_gui
    id: example_msg
    output_language: python
    title: WIFI_OFDM_Simulation
  states: {}

blocks:
- name: rate
  id: variable_qtgui_chooser
  parameters:
    label: PPDU Rate
    labels: '["6MBps", "9MBps", "12MBps", "18MBps", "24MBps", "36MBps", "48MBps", "54MBps"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '5000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    shift: 'False'
    type: complex
    window: ''
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'False'
    type: complex
    window: ''
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '25'
    minsize: '10'
  states: {}
- name: wifi_ofdm_block_decoder_vc_0
  id: wifi_ofdm_block_decoder_vc
  parameters: {}
  states: {}
- name: wifi_ofdm_coarse_cfo_fixer_cc_0
  id: wifi_ofdm_coarse_cfo_fixer_cc
  parameters:
    delay: '16'
  states: {}
- name: wifi_ofdm_cp_preamble_prefixer_vcc_0
  id: wifi_ofdm_cp_preamble_prefixer_vcc
  parameters:
    tag: '"packet_len"'
  states: {}
- name: wifi_ofdm_header_prefixer_0
  id: wifi_ofdm_header_prefixer
  parameters: {}
  states: {}
- name: wifi_ofdm_ppdu_builder_0
  id: wifi_ofdm_ppdu_builder
  parameters:
    rate: rate
    seed: '255'
  states: {}
- name: wifi_ofdm_ppdu_sink_0
  id: wifi_ofdm_ppdu_sink
  parameters: {}
  states: {}
- name: wifi_ofdm_symbol_mapper_bvc_0
  id: wifi_ofdm_symbol_mapper_bvc
  parameters:
    tag: '"packet_len"'
  states: {}
- name: wifi_ofdm_symbol_parser_vc_0
  id: wifi_ofdm_symbol_parser_vc
  parameters: {}
  states: {}
- name: wifi_ofdm_symbol_sync_cvc_0
  id: wifi_ofdm_symbol_sync_cvc
  parameters: {}
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', wifi_ofdm_coarse_cfo_fixer_cc_0, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', wifi_ofdm_coarse_cfo_fixer_cc_0, '0']
- [fft_vxx_0, '0', wifi_ofdm_cp_preamble_prefixer_vcc_0, '0']
- [fft_vxx_1, '0', wifi_ofdm_symbol_parser_vc_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', wifi_ofdm_symbol_mapper_bvc_0, '0']
- [pdu_random_pdu_0, pdus, wifi_ofdm_ppdu_builder_0, plcp_in]
- [wifi_ofdm_block_decoder_vc_0, ppdu_out, wifi_ofdm_ppdu_sink_0, ppdu_in]
- [wifi_ofdm_coarse_cfo_fixer_cc_0, '0', wifi_ofdm_symbol_sync_cvc_0, '0']
- [wifi_ofdm_cp_preamble_prefixer_vcc_0, '0', blocks_throttle2_0, '0']
- [wifi_ofdm_header_prefixer_0, plcp_out, pdu_pdu_to_tagged_stream_0, pdus]
- [wifi_ofdm_ppdu_builder_0, ppdu_out, wifi_ofdm_header_prefixer_0, psdu_in]
- [wifi_ofdm_ppdu_sink_0, plcp_out, blocks_message_debug_0, print]
- [wifi_ofdm_symbol_mapper_bvc_0, '0', fft_vxx_0, '0']
- [wifi_ofdm_symbol_parser_vc_0, '0', wifi_ofdm_block_decoder_vc_0, '0']
- [wifi_ofdm_symbol_sync_cvc_0, '0', fft_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
