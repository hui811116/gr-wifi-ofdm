<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_ofdm_usrp_tx</value></param>
<param><key>author</key><value>Teng-Hui Huang</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>WIFI OfDM USRP Tx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>value</key><value>"name=NI290101"</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>drate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Data rate</value></param>
<param><key>labels</key><value>['6Mbps','9Mbps','12Mbps','18Mbps','24Mbps','36Mbps','48Mbps','54Mbps']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2,3,4,5,6,7]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>value</key><value>"A:A"</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>20</value></param>
<param><key>minsize</key><value>20</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>gadget_burst_tagger_cc</key>
<param><key>id</key><value>gadget_burst_tagger_cc_0</value></param>
<param><key>mult</key><value>sps</value></param>
<param><key>tagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>tx_subdev</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>wifi_ofdm_cp_preamble_prefixer_vcc</key>
<param><key>id</key><value>wifi_ofdm_cp_preamble_prefixer_vcc_0</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<block>
<key>wifi_ofdm_header_prefixer</key>
<param><key>id</key><value>wifi_ofdm_header_prefixer_0</value></param>
</block>
<block>
<key>wifi_ofdm_ppdu_builder</key>
<param><key>id</key><value>wifi_ofdm_ppdu_builder_0</value></param>
<param><key>rate</key><value>drate</value></param>
<param><key>seed</key><value>87</value></param>
</block>
<block>
<key>wifi_ofdm_symbol_mapper_bvc</key>
<param><key>id</key><value>wifi_ofdm_symbol_mapper_bvc_0</value></param>
<param><key>tag</key><value>"packet_len"</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>wifi_ofdm_symbol_mapper_bvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>wifi_ofdm_ppdu_builder_0</sink_block_id><source_key>pdus</source_key><sink_key>plcp_in</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>wifi_ofdm_cp_preamble_prefixer_vcc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gadget_burst_tagger_cc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>gadget_burst_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_cp_preamble_prefixer_vcc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_ofdm_header_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>ppdu_out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>wifi_ofdm_ppdu_builder_0</source_block_id><sink_block_id>wifi_ofdm_header_prefixer_0</sink_block_id><source_key>ppdu_out</source_key><sink_key>psdu_in</sink_key></connection>
<connection><source_block_id>wifi_ofdm_symbol_mapper_bvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
